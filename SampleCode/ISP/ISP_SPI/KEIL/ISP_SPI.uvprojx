# Keil uVision project ISP_SPI.uvprojx, settings and files
target ISP_SPI (6190000::V6.19::ARMCLANG)
  device: NANO112LC2AN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x7FFF) CLOCK(32000000) CPUTYPE("Cortex-M0")
  output: NANO112_ISP_SPI
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c define: TARGET_NANO112
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\Nano1X2Series\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_Nano1x2Series_ISP.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano1X2Series/Source/: system_Nano1X2Series.c
    ../../../../Library/Device/Nuvoton/Nano1X2Series/Source/ARM/: startup_Nano1X2Series_ISP.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c spi_transfer.c
  group Library
    ../../../../Library/StdDriver/src/: fmc.c gpio.c spi.c sys.c timer.c clk.c
