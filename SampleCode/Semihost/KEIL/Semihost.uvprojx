# Keil uVision project Semihost.uvprojx, settings and files
target Semihost (6190000::V6.19::ARMCLANG)
  device: NANO112VC2AN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Semihost
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\Library\Device\Nuvoton\Nano1X2Series\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\CMSIS\Include
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_Nano1x2Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/Nano1X2Series/Source/: system_Nano1X2Series.c
    ../../../Library/Device/Nuvoton/Nano1X2Series/Source/ARM/: startup_Nano1X2Series.s
  group Libraries
    ../../../Library/StdDriver/src/: retarget.c sys.c
  group User
    ../: main.c
